# Keil uVision project ISADII_Bootloader.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ISADIIBootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_USB_OTG_FS
  c include: .\FATFS\doc;.\FATFS\exfuns;.\FATFS\src;.\FATFS\src\option;.\HMI_DRIVE\inc;.\USART;.\USB\STM32_USB_HOST_Library\Class\MSC\inc;.\USB\STM32_USB_HOST_Library\Core\inc;.\USB\STM32_USB_OTG_Driver\inc;.\USB\USB_APP;..\RC15DFU;.\STMCORE\inc;.\STMLIBRARY\inc;.\FreeRTOS\include;.\FreeRTOS\Core;.\FreeRTOS\portable\MemMang;.\FreeRTOS\portable\RVDS\ARM_CM4F;.\IAP;.\stmflash;.\delay;.\MALLOC;.\Flash;.\Bell
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MAIN
    ./: MAIN.c BSP.c
    ./IAP/: iap.c
    ./stmflash/: stmflash.c
  group USB\OTG
    ./USB/STM32_USB_OTG_Driver/src/: usb_hcd.c usb_core.c usb_hcd_int.c
  group USB\HOST
    ./USB/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ./USB/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group USB\APP
    ./USB/USB_APP/: usbh_usr.c usb_bsp.c
    ./delay/: delay.c sys.c
  group HMI_DRIVE
    ./HMI_DRIVE/src/: cmd_queue.c hmi_APP.c hmi_driver.c
  group USART
    ./USART/: usart.c
  group FATFS
    ./FATFS/src/: diskio.c ff.c
    ./FATFS/src/option/: cc936.c
    ./FATFS/exfuns/: exfuns.c fattester.c
    ./Flash/: w25qxx.c spi.c
  group STMCORE
    ./STMCORE/src/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s
  group STMLIBRARY
    ./STMLIBRARY/src/: misc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_spi.c
  group MALLOC
    ./MALLOC/: malloc.c
  group Bell
    ./Bell/: Bell.c
